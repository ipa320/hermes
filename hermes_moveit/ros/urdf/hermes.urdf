Commit message: show real hermes pos in rviz

File: hermes_moveit/ros/urdf/hermes.urdf (robot description, URDF)
Before this commit: robot hermesArm, 109 links, 108 joints
Links:
- link pillar: mass 1.0 -> None
